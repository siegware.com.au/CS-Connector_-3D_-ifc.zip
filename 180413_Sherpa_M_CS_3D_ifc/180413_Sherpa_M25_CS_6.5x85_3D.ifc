Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-07-07T10:25:31
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_M25_CS_6.5x85_3D
Description: 180413_Sherpa_M25_CS_6.5x85_3D

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_M25_CS_6.5x85_3D
Type - PredefinedType: USERDEFINED
Description: M25 CS
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025913; Aluminium: EN AW - 6082; Type: M25 CS; Number_of_Screws: 13; Locking_Screws: 1; 4x20-12mm: 10000025305; Concrete_Screws: 4; FBS_II_6x60-5_SK: 10000034831; 6.5x85mm: 10000032976; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
