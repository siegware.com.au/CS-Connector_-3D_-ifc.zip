Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-07-08T10:42:37
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XL170_CS_8x140_3D
Description: 180413_Sherpa_XL170_CS_8x140_3D

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XL170_CS_8x140_3D
Type - PredefinedType: USERDEFINED
Description: XL170 CS
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025926; Aluminium: EN AW - 5083; Type: XL170 CS; Number_of_Screws: 20; Locking_Screws: 2; 5x47.8-20mm: 10000025207; FBS_II_80x80_SK: 10000035596; FBS_II_10x80_SK: 10000035232; FH_II_12-15_SK: 10000025820; Concrete_Screws_Option_2: 6; Concrete_Screws_Option_3: 6; Concrete_Screws_Option_1: 8; 8.0x140mm: 10000023583; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
