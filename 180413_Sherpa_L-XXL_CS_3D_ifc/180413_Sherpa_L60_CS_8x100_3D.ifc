Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-07-07T11:25:33
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_L60_CS_8x100_3D
Description: 180413_Sherpa_L60_CS_8x100_3D

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_L60_CS_8x100_3D
Type - PredefinedType: USERDEFINED
Description: L60 CS
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025919; Aluminium: EN AW - 6082; Type: L60 CS; Number_of_Screws: 15; Locking_Screws: 2; Concrete_Screws: 6; 8.0x100mm: 10000023937; 5x47.8-20mm: 10000025306; FBS_II_80x80_SK: 10000035596; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
