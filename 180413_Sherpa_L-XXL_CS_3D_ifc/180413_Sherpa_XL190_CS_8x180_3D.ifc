Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-07-16T09:34:18
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XL190_CS_8x180_3D
Description: 180413_Sherpa_XL190_CS_8x180_3D

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XL190_CS_8x180_3D
Type - PredefinedType: USERDEFINED
Description: XL190 CS
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025927; Aluminium: EN AW - 5083; Type: XL190 CS; Number_of_Screws: 22; Locking_Screws: 2; 5x47.8-20mm: 10000025207; FBS_II_80x80_SK: 10000035596; FBS_II_10x80_SK: 10000035232; FH_II_12-15_SK: 10000025820; Concrete_Screws_Option_2: 8; Concrete_Screws_Option_3: 8; Concrete_Screws_Option_1: 10; 8.0x180mm: 10000026101; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
