Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-07-16T10:43:00
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XXL300_CS_8x160_3D
Description: 180413_Sherpa_XXL300_CS_8x160_3D

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XXL300_CS_8x160_3D
Type - PredefinedType: USERDEFINED
Description: XXL300 CS
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025934; Aluminium: EN AW - 5083; Type: XXL300 CS; Number_of_Screws: 33; Locking_Screws: 2; 5x47.8-20mm: 10000025207; FBS_II_80x80_SK: 10000035596; Concrete_Screws_Option_1: 18; 8.0x160mm: 10000021885; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
