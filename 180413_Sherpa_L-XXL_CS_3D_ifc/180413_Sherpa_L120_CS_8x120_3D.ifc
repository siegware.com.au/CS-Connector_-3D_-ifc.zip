Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-07-07T11:42:57
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_L120_CS_8x120_3D
Description: 180413_Sherpa_L120_CS_8x120_3D

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_L120_CS_8x120_3D
Type - PredefinedType: USERDEFINED
Description: L120 CS
SHERPA Connection Systems GmbH - Art.-Nr.: 10000034851; Aluminium: EN AW - 6082; Type: L120 CS; Number_of_Screws: 21; Locking_Screws: 2; Concrete_Screws: 8; 5x47.8-20mm: 10000025306; FBS_II_80x80_SK: 10000035596; 8.0x120mm: 10000032978; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
